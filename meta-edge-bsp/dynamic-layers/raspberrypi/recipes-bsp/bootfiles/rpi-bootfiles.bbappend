# Newer than the meta-raspberrypi pin (20260521): raspberrypi/firmware tag
# 1.20260915.
RPIFW_DATE = "20260915"
SRCREV = "6f0881cba8bea8ec24956a5718714730e9936ec5"
SRC_URI[sha256sum] = "b3a09ad959084de13733da42741d08d4be238037152701d6455bd337466b7741"
