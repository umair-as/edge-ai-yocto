CVE_STATUS[CVE-2016-7545] = "cpe-incorrect: CVE-2016-7545 concerns the SELinux sandbox launcher, not checkpolicy"
