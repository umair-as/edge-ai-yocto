CVE_STATUS[CVE-2016-7545] = "cpe-incorrect: the 3.10 policycoreutils recipe does not ship the sandbox launcher named by CVE-2016-7545"
