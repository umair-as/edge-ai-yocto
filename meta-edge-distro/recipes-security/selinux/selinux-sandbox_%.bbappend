CVE_STATUS[CVE-2016-7545] = "fixed-version: upstream SELinux commit acca96a135a4d2a028ba9b636886af99c0915379 is included in the shipped 3.10 source revision ca10fc4204ed60540d41d2499127c18ad0643f9e"
