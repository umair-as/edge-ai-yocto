FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Replace the default poky splash with the EDGE AI OS brand asset.
SPLASH_IMAGES = "file://psplash-edge-img.png;outsuffix=default"
