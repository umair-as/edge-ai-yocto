FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-gh-143921-Reject-control-characters-in-IMAP-commands.patch"

